# Keil uVision project STM32F11CEUb.uvprojx, settings and files
target STM32F411CEUb (6180000::V6.18::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F11CEUb
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group App
    ./: main.c clock.c gpio.c time.c
  group Headers
    ./: clock.h gpio.h time.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
