# Keil uVision project adc_functions.uvprojx, settings and files
target STM32F407 (6180000::V6.18::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: adc_functions
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ./: main.c gpio.c clock.c adc.c
  group Hearders
    ./: clock.h gpio.h adc.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
